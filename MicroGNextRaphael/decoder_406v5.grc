options:
  parameters:
    author: rclar
    generate_options: no_gui
    id: decoder_406v5
    output_language: python
    run_options: run
    title: decoder_406v5
  states: {}

blocks:
- name: carrier_frequency
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: cma_aa
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_rect_0
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {}
- name: cma_aa_1
  id: variable_adaptive_algorithm
  parameters:
    cons: digital.constellation_bpsk().base()
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {}
- name: damping_factor_0
  id: variable_qtgui_range
  parameters:
    label: d_f
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {state: disabled}
- name: decim
  id: variable
  parameters:
    value: '85'
  states: {}
- name: decim_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/decim
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/decim/8
    win: window.WIN_HAMMING
  states: {}
- name: loop_bandwidth_0
  id: variable_qtgui_range
  parameters:
    label: l_b
    start: '0'
    step: '.0001'
    stop: '1'
    value: 2*math.pi*.04
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx_gain
    start: '0'
    step: '1'
    stop: '70'
    value: '37'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '680000'
  states: {}
- name: samples_per_bit
  id: variable
  parameters:
    value: '1700'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '850'
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-1, +1,]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: '-50'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: 8*sps
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_rect_0
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '010101100110101010'
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '010101100110101010'
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      This is our costas loop that corrects the frequency offset
      coming from the imperfect receiver. This looks very
      close to our original signal now! All we need to do now
      is to sample the signal at the correct times
      in order to recover the symbols.
    order: '2'
    w: '.350'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: 'False'
    alg: cma_aa
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Our symbol synchronization figures out the timing
      to sample the signal. After this samples the signal, you can
      see that we get back the original repeating
      [1, -1, -1, 1, -1, 1] sequence! However, we still need to convert
      the Manchester encoded symbols back into 1's and 0's.
    damping: damping_factor_0
    loop_bw: loop_bandwidth_0
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '850'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Our symbol synchronization figures out the timing
      to sample the signal. After this samples the signal, you can
      see that we get back the original repeating
      [1, -1, -1, 1, -1, 1] sequence! However, we still need to convert
      the Manchester encoded symbols back into 1's and 0's.
    damping: '1'
    loop_bw: 2*math.pi*.04
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '850'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000 '
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '406025000'
    gain1: '''fast_attack'''
    len_tag_key: '""'
    manual_gain1: '37'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.4.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[1/sps,] * int(sps)'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10*samp_rate/sps
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2*samp_rate/sps
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '5005'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '5006'
    type: byte
  states: {}
- name: packet_extractor
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      from colorama import Fore, Style, init

      # Initialize Colorama (for colored debug output in console)
      init(autoreset=True)

      class ManchesterDecoderBlock(gr.basic_block):
          def __init__(self, tag_name="packet_len"):
              gr.basic_block.__init__(
                  self,
                  name="ManchesterDecoder",
                  in_sig=[np.uint8],   # input: stream of 8-bit (char) samples (0 or 1)
                  out_sig=[np.uint8]   # output: stream of 8-bit decoded bytes
              )
              self.tag_name = pmt.intern(tag_name)
              self.set_tag_propagation_policy(gr.TPP_DONT)   # handle tags manually&#8203;:contentReference[oaicite:6]{index=6}

              # State for collecting packet bits
              self._collecting = False
              self._buffer = []       # buffer for Manchester bits of the current packet
              self._needed_bits = 0   # how many more bits are needed to complete current packet

              # Ensure output buffer can accommodate full packets (15 bytes)
              self.set_output_multiple(15)

          def forecast(self, noutput_items, ninput_items):
              """
              Tell GR how many input items are required on each input port
              to produce noutput_items on the output port.

              Since we only ever want to process full 240‐sample bursts:
                - If we’re not currently collecting a packet, we need 240 samples
                - If we’re mid‐packet, we need however many bits remain
              """
              if self._collecting:
                  # we’re in the middle of gathering a packet:
                  needed = self._needed_bits
              else:
                  # waiting for a new packet start → need full burst
                  needed = 240

              # return a tuple (one entry per input port)
              return (needed,)


          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_in = len(in0)

              # If not currently in a packet, look for a 'packet_len' tag to start a new burst
              if not self._collecting:
                  # No ongoing packet, search for the start tag in this input window
                  tags = self.get_tags_in_window(0, 0, n_in, self.tag_name)
                  if len(tags) == 0:
                      # No packet start tag found in this chunk
                      if n_in > 0:
                          # print(Fore.YELLOW + f"No packet tag found in {n_in} samples – dropping them." + Style.RESET_ALL)
                          self.consume(0, n_in)  # discard irrelevant samples
                      return 0  # no output produced

                  # We found at least one tag; consider the first tag as start of a new packet
                  tags.sort(key=lambda t: t.offset)
                  tag = tags[0]
                  tag_offset = tag.offset - self.nitems_read(0)  # relative index of tag in the buffer&#8203;:contentReference[oaicite:7]{index=7}
                  if tag_offset > 0:
                      # Skip any samples preceding the tag (shouldn't contain valid data)
                      # print(Fore.MAGENTA + f"Skipping {tag_offset} pre-tag sample(s) (noise/preamble)." + Style.RESET_ALL)
                      self.consume(0, tag_offset)
                      # Adjust input array to start at the tag position
                      in0 = in0[tag_offset:]
                      n_in -= tag_offset
                      tag_offset = 0

                  # Initialize a new packet collection
                  self._collecting = True
                  # Determine expected packet length from tag (should be 240)
                  pkt_len = pmt.to_python(tag.value)
                  if isinstance(pkt_len, (list, tuple)):  # safety: convert PMT vector or u64 to int
                      pkt_len = int(pkt_len[0] if pkt_len else 0)
                  else:
                      pkt_len = int(pkt_len)
                  expected_bits = pkt_len
                  if expected_bits != 240:
                      # Log a warning if the tag length is not the expected 240
                      print(Fore.YELLOW + f"Warning: tag indicates {expected_bits} bits (expected 240)." + Style.RESET_ALL)
                  self._needed_bits = expected_bits
                  self._buffer = []
                  print(Fore.CYAN + f"Packet start detected (tag at input 0). Expecting {expected_bits} Manchester bits..." + Style.RESET_ALL)

                  # Process available bits in this call for the new packet
                  if n_in >= self._needed_bits:
                      # We have the entire 240-bit burst in this chunk
                      needed = self._needed_bits
                      bits_chunk = in0[:needed]
                      self._buffer.extend(bits_chunk.tolist())
                      print(Fore.CYAN + f"Collected all {needed} bits for packet, decoding..." + Style.RESET_ALL)
                      self._decode_and_output_packet(out0)  # decode and write output bytes
                      # Consume the 240 input bits used for this packet
                      self.consume(0, needed)
                      # (If there are extra bits beyond this packet in 'in0', leave them for the next call)
                      return len(out0[:15])  # produced 15 bytes (or 0 if decode failed)
                  else:
                      # Only a partial burst is available; buffer it and wait for more
                      self._buffer.extend(in0.tolist())
                      self._needed_bits -= n_in
                      print(Fore.CYAN + f"Collected {n_in} bits (partial packet). Waiting for {self._needed_bits} more bits..." + Style.RESET_ALL)
                      self.consume(0, n_in)  # consume all available input
                      # No output yet (packet not complete)
                      return 0

              else:
                  # We are in the middle of gathering a packet (a previous tag was seen)
                  if n_in == 0:
                      return 0  # nothing to do

                  if n_in >= self._needed_bits:
                      # This chunk provides the remaining bits to finish the packet
                      needed = self._needed_bits
                      bits_chunk = in0[:needed]
                      self._buffer.extend(bits_chunk.tolist())
                      print(Fore.CYAN + f"Received final {needed} bits, packet complete. Decoding..." + Style.RESET_ALL)
                      self._decode_and_output_packet(out0)
                      self.consume(0, needed)  # consume only the bits used for this packet
                      return len(out0[:15])  # 15 bytes output (or 0 if decode failed)
                  else:
                      # Still not enough to finish; accumulate and continue waiting
                      self._buffer.extend(in0.tolist())
                      self._needed_bits -= n_in
                      print(Fore.CYAN + f"Received {n_in} more bits (total collected {len(self._buffer)}). Still need {self._needed_bits} bits..." + Style.RESET_ALL)
                      self.consume(0, n_in)
                      return 0

          def _decode_and_output_packet(self, out_buffer):
              """
              Decode the 240-bit Manchester buffer into 15 bytes and output to out_buffer.
              Attaches an output tag and prints debug info. If decode fails, drops packet.
              """
              # We expect exactly 240 bits in the buffer when called
              bits = self._buffer
              self._collecting = False   # reset state for next packet
              self._needed_bits = 0

              if len(bits) != 240:
                  # Safety check (should not happen if logic is correct)
                  print(Fore.RED + f"Error: Collected {len(bits)} bits, expected 240. Dropping packet." + Style.RESET_ALL)
                  self._buffer = []
                  return

              # Manchester decode: map (0,1)->0 and (1,0)->1
                      # Manchester decode with “flatten‐to‐0” on invalid pairs
              decoded_bits = []
              for i in range(0, 240, 2):
                  b0 = bits[i]
                  b1 = bits[i+1]
                  if (b0, b1) == (0, 1):
                      decoded_bits.append(0)
                  elif (b0, b1) == (1, 0):
                      decoded_bits.append(1)
                  else:
                      # Invalid pair: flatten to 0 and keep going
                      decoded_bits.append(0)
                      # print(Fore.YELLOW + f"[MD][WARN] Invalid pair at {i}:({b0},{b1}), flattened to 0." + Style.RESET_ALL)


              # Clear buffer for next packet regardless of outcome
              self._buffer = []


              # Pack 120 decoded bits into 15 bytes (MSB-first in each byte)
              decoded_bytes = []
              for j in range(0, 120, 8):
                  byte_val = 0
                  for bit in decoded_bits[j:j+8]:
                      byte_val = (byte_val << 1) | bit
                  decoded_bytes.append(byte_val)
              decoded_bytes = np.array(decoded_bytes, dtype=np.uint8)  # 15-byte array

              # Add a 'packet_len' tag to mark this 15-byte packet on output&#8203;:contentReference[oaicite:8]{index=8}
              self.add_item_tag(
                  0, 
                  self.nitems_written(0),             # absolute position of first output byte
                  self.tag_name, 
                  pmt.from_long(len(decoded_bytes))   # value = 15
              )
              # Output the decoded bytes
              out_buffer[:len(decoded_bytes)] = decoded_bytes
              # Debug output of the decoded payload
              print(Fore.GREEN + f"Decoded Standard packet -> {len(decoded_bits)} bits into {len(decoded_bytes)} bytes: " 
                    + ' '.join(f'0x{b:02X}' for b in decoded_bytes) + Style.RESET_ALL)
              print(Fore.GREEN + f"Emitted packet of {len(decoded_bytes)} byte(s).\n" + Style.RESET_ALL)
    tag_name: '"packet_len"'
  states: {}
- name: packet_extractor_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      from colorama import Fore, Style, init

      # Initialize Colorama (for colored debug output in console)
      init(autoreset=True)

      class ManchesterDecoderBlock(gr.basic_block):
          def __init__(self, tag_name="packet_len"):
              gr.basic_block.__init__(
                  self,
                  name="ManchesterDecoder",
                  in_sig=[np.uint8],   # input: stream of 8-bit (char) samples (0 or 1)
                  out_sig=[np.uint8]   # output: stream of 8-bit decoded bytes
              )
              self.tag_name = pmt.intern(tag_name)
              self.set_tag_propagation_policy(gr.TPP_DONT)   # handle tags manually&#8203;:contentReference[oaicite:6]{index=6}

              # State for collecting packet bits
              self._collecting = False
              self._buffer = []       # buffer for Manchester bits of the current packet
              self._needed_bits = 0   # how many more bits are needed to complete current packet

              # Ensure output buffer can accommodate full packets (15 bytes)
              self.set_output_multiple(15)

          def forecast(self, noutput_items, ninput_items):
              """
              Tell GR how many input items are required on each input port
              to produce noutput_items on the output port.

              Since we only ever want to process full 240‐sample bursts:
                - If we’re not currently collecting a packet, we need 240 samples
                - If we’re mid‐packet, we need however many bits remain
              """
              if self._collecting:
                  # we’re in the middle of gathering a packet:
                  needed = self._needed_bits
              else:
                  # waiting for a new packet start → need full burst
                  needed = 240

              # return a tuple (one entry per input port)
              return (needed,)


          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_in = len(in0)

              # If not currently in a packet, look for a 'packet_len' tag to start a new burst
              if not self._collecting:
                  # No ongoing packet, search for the start tag in this input window
                  tags = self.get_tags_in_window(0, 0, n_in, self.tag_name)
                  if len(tags) == 0:
                      # No packet start tag found in this chunk
                      if n_in > 0:
                          # print(Fore.YELLOW + f"No packet tag found in {n_in} samples – dropping them." + Style.RESET_ALL)
                          self.consume(0, n_in)  # discard irrelevant samples
                      return 0  # no output produced

                  # We found at least one tag; consider the first tag as start of a new packet
                  tags.sort(key=lambda t: t.offset)
                  tag = tags[0]
                  tag_offset = tag.offset - self.nitems_read(0)  # relative index of tag in the buffer&#8203;:contentReference[oaicite:7]{index=7}
                  if tag_offset > 0:
                      # Skip any samples preceding the tag (shouldn't contain valid data)
                      print(Fore.MAGENTA + f"Skipping {tag_offset} pre-tag sample(s) (noise/preamble)." + Style.RESET_ALL)
                      self.consume(0, tag_offset)
                      # Adjust input array to start at the tag position
                      in0 = in0[tag_offset:]
                      n_in -= tag_offset
                      tag_offset = 0

                  # Initialize a new packet collection
                  self._collecting = True
                  # Determine expected packet length from tag (should be 240)
                  pkt_len = pmt.to_python(tag.value)
                  if isinstance(pkt_len, (list, tuple)):  # safety: convert PMT vector or u64 to int
                      pkt_len = int(pkt_len[0] if pkt_len else 0)
                  else:
                      pkt_len = int(pkt_len)
                  expected_bits = pkt_len
                  if expected_bits != 240:
                      # Log a warning if the tag length is not the expected 240
                      print(Fore.YELLOW + f"Warning: tag indicates {expected_bits} bits (expected 240)." + Style.RESET_ALL)
                  self._needed_bits = expected_bits
                  self._buffer = []
                  print(Fore.CYAN + f"Packet start detected (tag at input 0). Expecting {expected_bits} Manchester bits..." + Style.RESET_ALL)

                  # Process available bits in this call for the new packet
                  if n_in >= self._needed_bits:
                      # We have the entire 240-bit burst in this chunk
                      needed = self._needed_bits
                      bits_chunk = in0[:needed]
                      self._buffer.extend(bits_chunk.tolist())
                      print(Fore.CYAN + f"Collected all {needed} bits for packet, decoding..." + Style.RESET_ALL)
                      self._decode_and_output_packet(out0)  # decode and write output bytes
                      # Consume the 240 input bits used for this packet
                      self.consume(0, needed)
                      # (If there are extra bits beyond this packet in 'in0', leave them for the next call)
                      return len(out0[:15])  # produced 15 bytes (or 0 if decode failed)
                  else:
                      # Only a partial burst is available; buffer it and wait for more
                      self._buffer.extend(in0.tolist())
                      self._needed_bits -= n_in
                      print(Fore.CYAN + f"Collected {n_in} bits (partial packet). Waiting for {self._needed_bits} more bits..." + Style.RESET_ALL)
                      self.consume(0, n_in)  # consume all available input
                      # No output yet (packet not complete)
                      return 0

              else:
                  # We are in the middle of gathering a packet (a previous tag was seen)
                  if n_in == 0:
                      return 0  # nothing to do

                  if n_in >= self._needed_bits:
                      # This chunk provides the remaining bits to finish the packet
                      needed = self._needed_bits
                      bits_chunk = in0[:needed]
                      self._buffer.extend(bits_chunk.tolist())
                      print(Fore.CYAN + f"Received final {needed} bits, packet complete. Decoding..." + Style.RESET_ALL)
                      self._decode_and_output_packet(out0)
                      self.consume(0, needed)  # consume only the bits used for this packet
                      return len(out0[:15])  # 15 bytes output (or 0 if decode failed)
                  else:
                      # Still not enough to finish; accumulate and continue waiting
                      self._buffer.extend(in0.tolist())
                      self._needed_bits -= n_in
                      print(Fore.CYAN + f"Received {n_in} more bits (total collected {len(self._buffer)}). Still need {self._needed_bits} bits..." + Style.RESET_ALL)
                      self.consume(0, n_in)
                      return 0

          def _decode_and_output_packet(self, out_buffer):
              """
              Decode the 240-bit Manchester buffer into 15 bytes and output to out_buffer.
              Attaches an output tag and prints debug info. If decode fails, drops packet.
              """
              # We expect exactly 240 bits in the buffer when called
              bits = self._buffer
              self._collecting = False   # reset state for next packet
              self._needed_bits = 0

              if len(bits) != 240:
                  # Safety check (should not happen if logic is correct)
                  print(Fore.RED + f"Error: Collected {len(bits)} bits, expected 240. Dropping packet." + Style.RESET_ALL)
                  self._buffer = []
                  return

              # Manchester decode: map (0,1)->0 and (1,0)->1
                      # Manchester decode with “flatten‐to‐0” on invalid pairs
              decoded_bits = []
              for i in range(0, 240, 2):
                  b0 = bits[i]
                  b1 = bits[i+1]
                  if (b0, b1) == (0, 1):
                      decoded_bits.append(0)
                  elif (b0, b1) == (1, 0):
                      decoded_bits.append(1)
                  else:
                      # Invalid pair: flatten to 0 and keep going
                      decoded_bits.append(0)
                      # print(Fore.YELLOW + f"[MD][WARN] Invalid pair at {i}:({b0},{b1}), flattened to 0." + Style.RESET_ALL)


              # Clear buffer for next packet regardless of outcome
              self._buffer = []


              # Pack 120 decoded bits into 15 bytes (MSB-first in each byte)
              decoded_bytes = []
              for j in range(0, 120, 8):
                  byte_val = 0
                  for bit in decoded_bits[j:j+8]:
                      byte_val = (byte_val << 1) | bit
                  decoded_bytes.append(byte_val)
              decoded_bytes = np.array(decoded_bytes, dtype=np.uint8)  # 15-byte array

              # Add a 'packet_len' tag to mark this 15-byte packet on output&#8203;:contentReference[oaicite:8]{index=8}
              self.add_item_tag(
                  0, 
                  self.nitems_written(0),             # absolute position of first output byte
                  self.tag_name, 
                  pmt.from_long(len(decoded_bytes))   # value = 15
              )
              # Output the decoded bytes
              out_buffer[:len(decoded_bytes)] = decoded_bytes
              # Debug output of the decoded payload
              print(Fore.GREEN + f"Decoded Inverted packet -> {len(decoded_bits)} bits into {len(decoded_bytes)} bytes: " 
                    + ' '.join(f'0x{b:02X}' for b in decoded_bytes) + Style.RESET_ALL)
              print(Fore.GREEN + f"Emitted packet of {len(decoded_bytes)} byte(s).\n" + Style.RESET_ALL)
    tag_name: '"packet_len"'
  states: {}
- name: qtgui_const_sink_x_2_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3,1,1,1
    name: '"Received Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,1,1,1
    name: '"Match Filtered Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 6,1,1,1
    name: '"Sampled Constellation"'
    size: '50'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 5,1,1,1
    name: '"Post Costas Loop Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    name: '"Received Signal"'
    size: '8192'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0,1,1
    name: '"Match Filtered Signal"'
    size: '8192'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 6,0,1,1
    marker1: '0'
    name: '"Sampled Manchester Symbols"'
    size: '512'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,1
    name: '"Post Costas Loop Signal"'
    size: '8192'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: tag_setter
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      #
      # TagRewriter.py
      # Simply copies the stream and rewrites any ‘packet_len’ tag to value=240.

      import numpy as np
      from gnuradio import gr
      import pmt

      class TagRewriter(gr.basic_block):
          def __init__(self, tag_key="packet_len", new_len=240):
              gr.basic_block.__init__(
                  self,
                  name="TagRewriter",
                  in_sig =[np.int8],    # 1‐byte symbols in
                  out_sig=[np.int8]     # 1‐byte symbols out
              )
              self.key     = pmt.intern(tag_key)
              self.new_val = pmt.from_long(int(new_len))
              # disable auto‐forward of tags
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def forecast(self, noutput_items, ninput_items):
              # request equal number of inputs for outputs
              return (noutput_items,)

          def general_work(self, input_items, output_items):
              in0  = input_items[0]
              out0 = output_items[0]
              # only process as many as both buffers allow
              n = min(len(in0), len(out0))
              if n == 0:
                  return 0

              # 1) copy samples one-by-one (avoids shape-broadcast errors)
              for i in range(n):
                  out0[i] = in0[i]

              # 2) find any 'packet_len' tags in this window [0..n)
              tags = self.get_tags_in_window(0, 0, n)
              for t in tags:
                  if t.key == self.key:
                      # relative offset from start of this window
                      rel_off = int(t.offset - self.nitems_read(0))
                      # absolute offset in output stream
                      abs_off = self.nitems_written(0) + rel_off
                      # re-add the same tag but with value=new_len
                      self.add_item_tag(0, abs_off, self.key, self.new_val)

              # 3) consume & produce
              self.consume(0, n)
              return n
    new_len: '240'
    tag_key: '"packet_len"'
  states: {}
- name: tag_setter_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      #
      # TagRewriter.py
      # Simply copies the stream and rewrites any ‘packet_len’ tag to value=240.

      import numpy as np
      from gnuradio import gr
      import pmt

      class TagRewriter(gr.basic_block):
          def __init__(self, tag_key="packet_len", new_len=240):
              gr.basic_block.__init__(
                  self,
                  name="TagRewriter",
                  in_sig =[np.int8],    # 1‐byte symbols in
                  out_sig=[np.int8]     # 1‐byte symbols out
              )
              self.key     = pmt.intern(tag_key)
              self.new_val = pmt.from_long(int(new_len))
              # disable auto‐forward of tags
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def forecast(self, noutput_items, ninput_items):
              # request equal number of inputs for outputs
              return (noutput_items,)

          def general_work(self, input_items, output_items):
              in0  = input_items[0]
              out0 = output_items[0]
              # only process as many as both buffers allow
              n = min(len(in0), len(out0))
              if n == 0:
                  return 0

              # 1) copy samples one-by-one (avoids shape-broadcast errors)
              for i in range(n):
                  out0[i] = in0[i]

              # 2) find any 'packet_len' tags in this window [0..n)
              tags = self.get_tags_in_window(0, 0, n)
              for t in tags:
                  if t.key == self.key:
                      # relative offset from start of this window
                      rel_off = int(t.offset - self.nitems_read(0))
                      # absolute offset in output stream
                      abs_off = self.nitems_written(0) + rel_off
                      # re-add the same tag but with value=new_len
                      self.add_item_tag(0, abs_off, self.key, self.new_val)

              # 3) consume & produce
              self.consume(0, n)
              return n
    new_len: '240'
    tag_key: '"packet_len"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: vsource
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: vsource
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [analog_pwr_squelch_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_const_sink_x_2_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_tag_gate_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_tag_gate_0, '0', qtgui_const_sink_x_2_0, '0']
- [blocks_tag_gate_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_tagged_stream_align_0, '0', packet_extractor, '0']
- [blocks_tagged_stream_align_0_0, '0', packet_extractor_0, '0']
- [blocks_xor_xx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [dc_blocker_xx_1, '0', digital_symbol_sync_xx_0_0, '0']
- [dc_blocker_xx_1, '0', digital_symbol_sync_xx_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_xor_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', tag_setter, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', tag_setter_0, '0']
- [digital_costas_loop_cc_0_0, '0', low_pass_filter_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_2_0_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_time_sink_x_2, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_linear_equalizer_0, '0']
- [iio_pluto_source_0, '0', blocks_tag_gate_0, '0']
- [interp_fir_filter_xxx_0, '0', dc_blocker_xx_1, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_2_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_2_0, '0']
- [low_pass_filter_0, '0', interp_fir_filter_xxx_0, '0']
- [packet_extractor, '0', network_tcp_sink_0, '0']
- [packet_extractor_0, '0', network_tcp_sink_0_0, '0']
- [tag_setter, '0', blocks_tagged_stream_align_0, '0']
- [tag_setter_0, '0', blocks_tagged_stream_align_0_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
